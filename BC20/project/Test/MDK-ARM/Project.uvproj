# Keil uVision project Project.uvproj, settings and files
target STM32L1XX_MD(STM32L1xxxBxx) (ARM-ADS)
  device: STM32L151RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152-EVAL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD, USE_STM32L152_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL;..\..\HARDWARE\usart;..\..\HARDWARE\TIMER;..\..\HARDWARE\BC20;..\..\HARDWARE\LED;..\..\HARDWARE\eink;..\..\HARDWARE\STRHEX;..\..\HARDWARE\dht11;..\..\HARDWARE\delay;..\..\HARDWARE\adc;..\..\HARDWARE\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group User
    ../: main.c stm32l1xx_it.c
    ../../HARDWARE/BC20/: BC20.c
  group StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c stm32l1xx_aes_util.c
  group CMSIS
    ../: system_stm32l1xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s startup_stm32l1xx_hd.s startup_stm32l1xx_xl.s
  group HARDWARE
    ../../HARDWARE/usart/: usart.c
    ../../HARDWARE/TIMER/: timer.c
    ../../HARDWARE/LED/: LED.c
    ../../HARDWARE/eink/: smp.c systempz.c
    ../../HARDWARE/STRHEX/: HEXSTR.c
    ../../HARDWARE/delay/: delay.c
    ../../HARDWARE/dht11/: dht11.c
    ../../HARDWARE/adc/: ADCx.c
    ../../HARDWARE/OLED/: oled.c
target STM32L1XX_MDP(STM32L1xxxCxx) (ARM-ADS)
  device: STM32L152ZC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: STM32L1XX_MDP
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MDP
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
target STM32L1XX_HD(STM32L1xxxDxx) (ARM-ADS)
  device: STM32L152ZD STMicroelectronics
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: STM32L152D-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_HD, USE_STM32L152D_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
target STM32L1XX_XL(STM32L1xxxExx) (ARM-ADS)
  device: STM32L152ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: STM32L1XX_XL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_XL
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --diag_suppress=L6329
